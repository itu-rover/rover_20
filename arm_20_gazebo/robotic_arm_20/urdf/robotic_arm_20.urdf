Commit message: bugfix

File: arm_20_gazebo/robotic_arm_20/urdf/robotic_arm_20.urdf (robot description, URDF)
Before this commit: robot robotic_arm_20, 10 links, 9 joints
Links:
- link base_link: geometry collision mesh filename=package://robotic_arm_20/meshes/base_link.STL
